# Keil uVision project WOLF.uvprojx, settings and files
target WOLF (6140000::V6.14::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF)                                                                 CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: WOLF +hex
  c flags: Optim=5 oTime=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c misc: -Wno-float-equal -Wno-padded -Wno-implicit-float-conversion -Wno-gnu-compound-literal-initializer -Wno-cast-qual -Wno-implicit-fallthrough -Wno-cast-align -Wno-pedantic -Wno-missing-noreturn -Wno-sign-conversion -Wno-date-time
  c include: ../Inc;                                                                                                                                                                                                                                                                                                                                                                       ../Drivers/STM32H7xx_HAL_Driver/Inc;                                                                                                                                                                                                                                                                                                                                                                       ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                                                                                                                                                                                                                                                                                                                                                       ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                                                                                                                                                                                                                                                                                                                                                       ../Drivers/CMSIS/Include;                                                                                                                                                                                                                                                                                                                                                                       ..\USBDevice;                                                                                                                                                                                                                                                                                                                                                                       ..\Src;                  ../Middlewares/Third_Party/FatFs/src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\WOLF\WOLF_custom.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: agc.c agc.h audio_filters.c audio_filters.h audio_processor.c audio_processor.h auto_notch.c auto_notch.h bands.c bands.h bootloader.c bootloader.h cw_decoder.c cw_decoder.h decoder.c decoder.h fft.c fft.h fonts.h front_unit.c front_unit.h fpga.c fpga.h fpga_flash.h functions.c functions.h i2c.c i2c.h images.h lcd.c lcd.h lcd_480x320.c lcd_800x480.c lcd_driver.c lcd_driver.h lcd_driver_ILI9481.c lcd_driver_ILI9481.h lcd_driver_RA8875.c lcd_driver_RA8875.h noise_blanker.c noise_blanker.h noise_reduction.c noise_reduction.h profiler.c profiler.h rf_unit.c rf_unit.h screen_layout.h screen_layout_480x320.h screen_layout_800x480.h sd.c sd.h settings.c settings.h spec_analyzer.c spec_analyzer.h swr_analyzer.c swr_analyzer.h system_menu.c system_menu.h touchpad.c touchpad.h touchpad_GT911.c touchpad_GT911.h trx_manager.c trx_manager.h usbd_audio_if.c usbd_audio_if.h usbd_cat_if.c usbd_cat_if.h usbd_debug_if.c usbd_debug_if.h usbd_ua3reo.c usbd_ua3reo.h vad.c vad.h wifi.c wifi.h wm8731.c wm8731.h main.c user_diskio.c fatfs.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Inc/: stm32h7xx_it.h stm32h7xx_hal_conf.h main.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group USBDevice
    ../USBDevice/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h
  group Middlewares/FatFs
    ../Inc/: user_diskio.h fatfs.h ffconf.h
    ../Middlewares/Third_Party/FatFs/src/: diskio.h ff.h ff_gen_drv.h integer.h diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
